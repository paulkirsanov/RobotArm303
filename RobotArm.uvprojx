# Keil uVision project RobotArm.uvprojx, settings and files
target RobotArm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RobotArm +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS\inc;.\Code\inc;.\FreeRTOS\inc;..\RobotArm;.\FreeRTOS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Code
    ./Code/src/: led.c main.c timer.c usart.c utils.c io.c stepmotor.c crc.c
  group CMSIS
    ./CMSIS/src/: core_cm4.c system_stm32f30x.c
  group StartUp
    ./Startup/: startup_stm32f303xc.s
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c tasks.c timers.c
